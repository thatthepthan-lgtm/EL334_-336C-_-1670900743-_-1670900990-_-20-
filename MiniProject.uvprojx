# Keil uVision project MiniProject.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group New Group
    C:/Users/Micro_404_006/Downloads/EL334_-336C-_-1670900743-_-1670900990-_-20-/EL334_-336C-_-1670900743-_-1670900990-_-20-/source/: buzzer.c led.c main.c melody.c safelock.c seg7.c switch.c timer.c board.h buzzer.h led.h melody.h safelock.h seg7.h switch.h timer.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
